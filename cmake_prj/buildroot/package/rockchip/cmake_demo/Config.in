## cmake_prj/buildroot/package/rockchip/cmake_demo/Config.in
```kconfig
config BR2_PACKAGE_CMAKE_DEMO
	bool "test cmake demo "
	help
		This is a deme to cmake project
```
